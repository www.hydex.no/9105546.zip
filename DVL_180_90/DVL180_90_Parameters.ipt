# Autodesk Inventor part: DVL180_90_Parameters
## iProperties
Created: 2009-09
Part Number: DVL180_90_Parameters
Document SubType Name: Modeling
Designer: TB
Density: 1 g/cm^3
Slaglengde: 100.000 mm
Vinkel_Plussport: 0.00 deg
Vinkel_Minusport: 0.00 deg
Forlengelse_rør: 0.000 mm
Author: TB
